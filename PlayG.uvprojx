# Keil uVision project PlayG.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F412ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x00040000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PlayG
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source Group 1
    ./: main.cpp lcd.cpp lcd.h
software components: CMSIS:CORE 5.0.2, CMSIS:DSP 1.5.2, Device:STM32Cube Framework:Classic 1.6.0, Device:STM32Cube HAL:ADC 1.6.0, Device:STM32Cube HAL:CAN 1.6.0, Device:STM32Cube HAL:CRC 1.6.0, Device:STM32Cube HAL:Common 1.6.0, Device:STM32Cube HAL:Cortex 1.6.0, Device:STM32Cube HAL:DFSDM 1.6.0, Device:STM32Cube HAL:DMA 1.6.0, Device:STM32Cube HAL:FMPI2C 1.6.0, Device:STM32Cube HAL:Flash 1.6.0, Device:STM32Cube HAL:GPIO 1.6.0, Device:STM32Cube HAL:HCD 1.6.0, Device:STM32Cube HAL:I2C 1.6.0, Device:STM32Cube HAL:I2S 1.6.0, Device:STM32Cube HAL:IRDA 1.6.0, Device:STM32Cube HAL:IWDG 1.6.0, Device:STM32Cube HAL:NAND 1.6.0, Device:STM32Cube HAL:PCD 1.6.0, Device:STM32Cube HAL:PWR 1.6.0, Device:STM32Cube HAL:QSPI 1.6.0, Device:STM32Cube HAL:RCC 1.6.0, Device:STM32Cube HAL:RNG 1.6.0, Device:STM32Cube HAL:RTC 1.6.0, Device:STM32Cube HAL:SD 1.6.0, Device:STM32Cube HAL:SPI 1.6.0, Device:STM32Cube HAL:Smartcard 1.6.0, Device:STM32Cube HAL:TIM 1.6.0, Device:STM32Cube HAL:UART 1.6.0, Device:STM32Cube HAL:USART 1.6.0, Device:STM32Cube HAL:WWDG 1.6.0, Device:Startup 2.6.0
